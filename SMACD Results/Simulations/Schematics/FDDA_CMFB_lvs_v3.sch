v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 -510 -150 {}
N 640 -200 640 -130 {lab=VDD}
N 670 -200 1070 -200 {lab=VDD}
N 1190 -200 1190 -130 {lab=VDD}
N 920 -200 920 -130 {lab=VDD}
N 560 -100 600 -100 {lab=V_PAD}
N 560 -100 560 -50 {lab=V_PAD}
N 560 -50 640 -50 {lab=V_PAD}
N 640 -70 640 0 {lab=V_PAD}
N 840 -100 880 -100 {lab=V_CMFB}
N 840 -100 840 -50 {lab=V_CMFB}
N 840 -50 920 -50 {lab=V_CMFB}
N 920 -70 920 -50 {lab=V_CMFB}
N 1120 -200 1170 -200 {lab=VDD}
N 640 -100 670 -100 {lab=VDD}
N 670 -200 670 -100 {lab=VDD}
N 920 -100 950 -100 {lab=VDD}
N 950 -200 950 -100 {lab=VDD}
N 1160 -100 1190 -100 {lab=VDD}
N 1160 -200 1160 -100 {lab=VDD}
N 920 -50 920 -20 {lab=V_CMFB}
N 1190 -20 1190 0 {lab=V_NAD}
N 1070 -200 1120 -200 {lab=VDD}
N 1190 -70 1190 -20 {lab=V_NAD}
N 1230 -100 1270 -100 {lab=V_NAD}
N 1270 -100 1270 -50 {lab=V_NAD}
N 1190 -50 1270 -50 {lab=V_NAD}
N 1090 970 1090 1000 {lab=V_NA}
N 730 970 730 1000 {lab=V_PA}
N 770 1030 1050 1030 {lab=V_B2}
N 730 1060 730 1100 {lab=VSS}
N 730 1100 1090 1100 {lab=VSS}
N 1090 1060 1090 1100 {lab=VSS}
N 910 1100 910 1160 {lab=VSS}
N 910 1000 910 1030 {lab=V_B2}
N 700 1030 700 1100 {lab=VSS}
N 700 1100 730 1100 {lab=VSS}
N 1120 1030 1120 1100 {lab=VSS}
N 1090 1100 1120 1100 {lab=VSS}
N 640 -200 670 -200 {lab=VDD}
N -680 -260 -680 -220 {lab=VDD}
N -260 -290 -260 -250 {lab=VDD}
N -720 -190 -680 -190 {lab=VDD}
N -720 -240 -720 -190 {lab=VDD}
N -720 -240 -680 -240 {lab=VDD}
N -260 -190 -210 -190 {lab=VDD}
N -260 -240 -210 -240 {lab=VDD}
N -210 -240 -210 -190 {lab=VDD}
N 140 -190 300 -190 {lab=V_CMFB}
N 140 -70 300 -70 {lab=V_B4}
N 140 50 300 50 {lab=V_B3}
N 100 -300 100 -260 {lab=VDD}
N 100 -320 340 -320 {lab=VDD}
N 340 -300 340 -260 {lab=VDD}
N 100 -140 100 -110 {lab=V_NE}
N 340 -140 340 -110 {lab=V_PE}
N 100 -150 100 -140 {lab=V_NE}
N 340 -150 340 -140 {lab=V_PE}
N 330 1100 330 1130 {lab=VSS}
N 130 1070 290 1070 {lab=V_B2}
N 100 90 100 150 {lab=V_SUM_P}
N 340 90 340 150 {lab=V_SUM_N}
N 60 -10 100 -10 {lab=V_ON}
N 340 -10 380 -10 {lab=V_OP}
N -640 -190 -300 -190 {lab=V_B1}
N -680 -270 -680 -260 {lab=VDD}
N -260 -250 -260 -220 {lab=VDD}
N 340 -260 340 -220 {lab=VDD}
N 100 -260 100 -220 {lab=VDD}
N 60 -190 100 -190 {lab=VDD}
N 60 -70 100 -70 {lab=VDD}
N 100 -110 100 -100 {lab=V_NE}
N 100 -160 100 -150 {lab=V_NE}
N 100 10 100 20 {lab=V_ON}
N 100 -20 100 -10 {lab=V_ON}
N 340 -20 340 -10 {lab=V_OP}
N 340 10 340 20 {lab=V_OP}
N 340 -110 340 -100 {lab=V_PE}
N 340 -160 340 -150 {lab=V_PE}
N 60 50 100 50 {lab=VSS}
N 50 1070 50 1120 {lab=VSS}
N 50 1070 90 1070 {lab=VSS}
N 90 1160 330 1160 {lab=VSS}
N 90 1100 90 1140 {lab=VSS}
N -80 -320 -50 -320 {lab=VDD}
N 220 -210 220 -190 {lab=V_CMFB}
N 220 -90 220 -70 {lab=V_B4}
N 220 30 220 50 {lab=V_B3}
N -30 1160 90 1160 {lab=VSS}
N 100 -40 100 -20 {lab=V_ON}
N 340 -40 340 -20 {lab=V_OP}
N 100 -10 100 10 {lab=V_ON}
N 340 -10 340 10 {lab=V_OP}
N 330 1030 330 1040 {lab=V_SUM_N}
N 90 1030 90 1040 {lab=V_SUM_P}
N 100 80 100 90 {lab=V_SUM_P}
N 340 80 340 90 {lab=V_SUM_N}
N 340 -190 380 -190 {lab=VDD}
N 340 -70 380 -70 {lab=VDD}
N 340 50 380 50 {lab=VSS}
N 370 1070 370 1120 {lab=VSS}
N 330 1070 370 1070 {lab=VSS}
N 100 -320 100 -300 {lab=VDD}
N 340 -320 340 -300 {lab=VDD}
N -80 -280 100 -280 {lab=VDD}
N -680 -320 -50 -320 {lab=VDD}
N -680 -320 -680 -270 {lab=VDD}
N -260 -320 -260 -290 {lab=VDD}
N -80 -320 -80 -280 {lab=VDD}
N -140 140 100 140 {lab=V_SUM_P}
N 90 1140 90 1160 {lab=VSS}
N 330 1130 330 1160 {lab=VSS}
N -40 120 340 120 {lab=V_SUM_N}
N -600 1160 -30 1160 {lab=VSS}
N 330 1160 910 1160 {lab=VSS}
N 340 -320 640 -320 {lab=VDD}
N 640 -320 640 -200 {lab=VDD}
N 60 -280 60 -190 {lab=VDD}
N 380 -320 380 -190 {lab=VDD}
N 60 -190 60 -70 {lab=VDD}
N 380 -190 380 -70 {lab=VDD}
N 50 1120 50 1160 {lab=VSS}
N 370 1120 370 1160 {lab=VSS}
N 30 50 60 50 {lab=VSS}
N 380 50 420 50 {lab=VSS}
N 380 -10 470 -10 {lab=V_OP}
N 470 -10 470 30 {lab=V_OP}
N 1170 -200 1190 -200 {lab=VDD}
N 790 -80 840 -80 {lab=V_CMFB}
N 210 1070 210 1090 {lab=V_B2}
N -4260 20 -4260 40 {lab=#net1}
N -3840 20 -3840 40 {lab=#net2}
N -3840 0 -3840 20 {lab=#net2}
N -4260 0 -4260 20 {lab=#net1}
N -4470 210 -4450 210 {lab=V_SUM_N}
N -4470 330 -4450 330 {lab=V_SUM_P}
N -4390 210 -4310 210 {lab=#net1}
N -4390 330 -4310 330 {lab=#net1}
N -4500 170 -4420 170 {lab=V_PN}
N -4530 210 -4530 270 {lab=#net1}
N -4530 270 -4530 330 {lab=#net1}
N -4500 210 -4500 230 {lab=VDD}
N -4500 230 -4420 230 {lab=VDD}
N -4420 210 -4420 230 {lab=VDD}
N -4420 230 -4280 230 {lab=VDD}
N -4500 310 -4500 330 {lab=VDD}
N -4500 310 -4420 310 {lab=VDD}
N -4420 310 -4420 330 {lab=VDD}
N -4420 310 -4280 310 {lab=VDD}
N -4500 370 -4420 370 {lab=V_PP}
N -4550 130 -4150 130 {lab=V_SUM_P}
N -4460 330 -4460 400 {lab=V_SUM_P}
N -4540 410 -4140 410 {lab=V_SUM_P}
N -4550 150 -4150 150 {lab=V_PP}
N -4460 400 -4460 410 {lab=V_SUM_P}
N -4550 390 -4150 390 {lab=V_PP}
N -4420 370 -4420 380 {lab=V_PP}
N -4420 380 -4420 390 {lab=V_PP}
N -4550 110 -4150 110 {lab=V_PN}
N -4540 430 -4140 430 {lab=V_PN}
N -4420 110 -4420 170 {lab=V_PN}
N -4530 270 -4170 270 {lab=#net1}
N -4570 270 -4530 270 {lab=#net1}
N -4910 210 -4890 210 {lab=V_SUM_N}
N -4690 330 -4670 330 {lab=V_SUM_N}
N -4690 210 -4670 210 {lab=V_SUM_P}
N -4910 330 -4890 330 {lab=V_SUM_P}
N -4830 210 -4750 210 {lab=#net1}
N -4830 330 -4750 330 {lab=#net1}
N -4940 170 -4860 170 {lab=V_PN}
N -4720 370 -4640 370 {lab=V_PN}
N -4970 210 -4970 270 {lab=#net1}
N -4970 270 -4970 330 {lab=#net1}
N -4790 210 -4790 270 {lab=#net1}
N -4790 270 -4790 330 {lab=#net1}
N -4610 210 -4610 270 {lab=#net1}
N -4610 270 -4610 330 {lab=#net1}
N -4940 210 -4940 230 {lab=VDD}
N -4940 230 -4860 230 {lab=VDD}
N -4860 210 -4860 230 {lab=VDD}
N -4860 230 -4720 230 {lab=VDD}
N -4720 210 -4720 230 {lab=VDD}
N -4640 210 -4640 230 {lab=VDD}
N -4720 230 -4640 230 {lab=VDD}
N -4940 310 -4940 330 {lab=VDD}
N -4940 310 -4860 310 {lab=VDD}
N -4860 310 -4860 330 {lab=VDD}
N -4860 310 -4720 310 {lab=VDD}
N -4720 310 -4720 330 {lab=VDD}
N -4720 310 -4640 310 {lab=VDD}
N -4640 310 -4640 330 {lab=VDD}
N -4720 170 -4640 170 {lab=V_PP}
N -4940 370 -4860 370 {lab=V_PP}
N -4680 140 -4680 210 {lab=V_SUM_P}
N -4990 130 -4590 130 {lab=V_SUM_P}
N -4900 330 -4900 400 {lab=V_SUM_P}
N -4980 410 -4580 410 {lab=V_SUM_P}
N -4990 150 -4590 150 {lab=V_PP}
N -4720 160 -4720 170 {lab=V_PP}
N -4900 400 -4900 410 {lab=V_SUM_P}
N -4680 130 -4680 140 {lab=V_SUM_P}
N -4720 150 -4720 160 {lab=V_PP}
N -4990 390 -4590 390 {lab=V_PP}
N -4860 370 -4860 380 {lab=V_PP}
N -4860 380 -4860 390 {lab=V_PP}
N -4990 110 -4590 110 {lab=V_PN}
N -4980 430 -4580 430 {lab=V_PN}
N -4860 110 -4860 170 {lab=V_PN}
N -4720 370 -4720 430 {lab=V_PN}
N -5130 330 -5110 330 {lab=V_SUM_N}
N -5130 210 -5110 210 {lab=V_SUM_P}
N -5270 210 -5190 210 {lab=#net1}
N -5270 330 -5190 330 {lab=#net1}
N -5160 370 -5080 370 {lab=V_PN}
N -5230 210 -5230 270 {lab=#net1}
N -5230 270 -5230 330 {lab=#net1}
N -5050 210 -5050 270 {lab=#net1}
N -5050 270 -5050 330 {lab=#net1}
N -5300 230 -5160 230 {lab=VDD}
N -5160 210 -5160 230 {lab=VDD}
N -5080 210 -5080 230 {lab=VDD}
N -5160 230 -5080 230 {lab=VDD}
N -5300 310 -5160 310 {lab=VDD}
N -5160 310 -5160 330 {lab=VDD}
N -5160 310 -5080 310 {lab=VDD}
N -5080 310 -5080 330 {lab=VDD}
N -5160 170 -5080 170 {lab=V_PP}
N -5120 140 -5120 210 {lab=V_SUM_P}
N -5430 130 -5030 130 {lab=V_SUM_P}
N -5420 410 -5020 410 {lab=V_SUM_P}
N -5430 150 -5030 150 {lab=V_PP}
N -5160 160 -5160 170 {lab=V_PP}
N -5120 130 -5120 140 {lab=V_SUM_P}
N -5160 150 -5160 160 {lab=V_PP}
N -5430 390 -5030 390 {lab=V_PP}
N -5430 110 -5030 110 {lab=V_PN}
N -5420 430 -5020 430 {lab=V_PN}
N -5160 370 -5160 430 {lab=V_PN}
N -5050 210 -4970 210 {lab=#net1}
N -5030 150 -4990 150 {lab=V_PP}
N -5030 130 -4990 130 {lab=V_SUM_P}
N -5030 110 -4990 110 {lab=V_PN}
N -5030 390 -4990 390 {lab=V_PP}
N -5020 410 -4980 410 {lab=V_SUM_P}
N -5020 430 -4980 430 {lab=V_PN}
N -5410 270 -5050 270 {lab=#net1}
N -4930 270 -4570 270 {lab=#net1}
N -4970 270 -4930 270 {lab=#net1}
N -5050 270 -4970 270 {lab=#net1}
N -5050 330 -4970 330 {lab=#net1}
N -4590 110 -4550 110 {lab=V_PN}
N -4590 130 -4550 130 {lab=V_SUM_P}
N -4590 150 -4550 150 {lab=V_PP}
N -4590 390 -4550 390 {lab=V_PP}
N -4580 410 -4540 410 {lab=V_SUM_P}
N -4580 430 -4540 430 {lab=V_PN}
N -5870 130 -5470 130 {lab=V_SUM_P}
N -5860 410 -5460 410 {lab=V_SUM_P}
N -5870 150 -5470 150 {lab=V_PP}
N -5870 390 -5470 390 {lab=V_PP}
N -5870 110 -5470 110 {lab=V_PN}
N -5860 430 -5460 430 {lab=V_PN}
N -6310 130 -5910 130 {lab=V_SUM_P}
N -6300 410 -5900 410 {lab=V_SUM_P}
N -6310 150 -5910 150 {lab=V_PP}
N -6310 390 -5910 390 {lab=V_PP}
N -6310 110 -5910 110 {lab=V_PN}
N -6300 430 -5900 430 {lab=V_PN}
N -5910 150 -5870 150 {lab=V_PP}
N -5910 130 -5870 130 {lab=V_SUM_P}
N -5910 110 -5870 110 {lab=V_PN}
N -5910 390 -5870 390 {lab=V_PP}
N -5900 410 -5860 410 {lab=V_SUM_P}
N -5900 430 -5860 430 {lab=V_PN}
N -6750 130 -6350 130 {lab=V_SUM_P}
N -6740 410 -6340 410 {lab=V_SUM_P}
N -6750 150 -6350 150 {lab=V_PP}
N -6750 390 -6350 390 {lab=V_PP}
N -6750 110 -6350 110 {lab=V_PN}
N -6740 430 -6340 430 {lab=V_PN}
N -5630 210 -5550 210 {lab=#net1}
N -5630 330 -5550 330 {lab=#net1}
N -5660 230 -5520 230 {lab=VDD}
N -5660 310 -5520 310 {lab=VDD}
N -7190 130 -6790 130 {lab=V_SUM_P}
N -7180 410 -6780 410 {lab=V_SUM_P}
N -7190 150 -6790 150 {lab=V_PP}
N -7190 390 -6790 390 {lab=V_PP}
N -7190 110 -6790 110 {lab=V_PN}
N -7180 430 -6780 430 {lab=V_PN}
N -6790 150 -6750 150 {lab=V_PP}
N -6790 130 -6750 130 {lab=V_SUM_P}
N -6790 110 -6750 110 {lab=V_PN}
N -6790 390 -6750 390 {lab=V_PP}
N -6780 410 -6740 410 {lab=V_SUM_P}
N -6780 430 -6740 430 {lab=V_PN}
N -5770 270 -5410 270 {lab=#net1}
N -6350 110 -6310 110 {lab=V_PN}
N -6350 130 -6310 130 {lab=V_SUM_P}
N -6350 150 -6310 150 {lab=V_PP}
N -6350 390 -6310 390 {lab=V_PP}
N -6340 410 -6300 410 {lab=V_SUM_P}
N -6340 430 -6300 430 {lab=V_PN}
N -5470 110 -5430 110 {lab=V_PN}
N -5470 130 -5430 130 {lab=V_SUM_P}
N -5470 150 -5430 150 {lab=V_PP}
N -5470 390 -5430 390 {lab=V_PP}
N -5460 410 -5420 410 {lab=V_SUM_P}
N -5460 430 -5420 430 {lab=V_PN}
N -4610 210 -4530 210 {lab=#net1}
N -4610 330 -4530 330 {lab=#net1}
N -4150 130 -4070 130 {lab=V_SUM_P}
N -7170 450 -4130 450 {lab=V_SUM_N}
N -5120 330 -5120 450 {lab=V_SUM_N}
N -4680 330 -4680 450 {lab=V_SUM_N}
N -7210 90 -4170 90 {lab=V_SUM_N}
N -4460 90 -4460 210 {lab=V_SUM_N}
N -4900 90 -4900 210 {lab=V_SUM_N}
N -7190 150 -7190 390 {lab=V_PP}
N -7210 410 -7180 410 {lab=V_SUM_P}
N -7210 130 -7210 410 {lab=V_SUM_P}
N -7210 130 -7190 130 {lab=V_SUM_P}
N -7230 110 -7190 110 {lab=V_PN}
N -7230 110 -7230 430 {lab=V_PN}
N -7230 430 -7180 430 {lab=V_PN}
N -7250 90 -7210 90 {lab=V_SUM_N}
N -7250 90 -7250 450 {lab=V_SUM_N}
N -7250 450 -7170 450 {lab=V_SUM_N}
N -4640 230 -4500 230 {lab=VDD}
N -4280 230 -4280 310 {lab=VDD}
N -4150 150 -4150 390 {lab=V_PP}
N -5670 210 -5670 230 {lab=VDD}
N -5670 230 -5660 230 {lab=VDD}
N -5700 170 -5700 210 {lab=#net1}
N -5700 170 -5670 170 {lab=#net1}
N -5680 310 -5680 330 {lab=VDD}
N -5680 310 -5660 310 {lab=VDD}
N -5710 370 -5680 370 {lab=#net1}
N -5710 330 -5710 370 {lab=#net1}
N -4310 210 -4290 210 {lab=#net1}
N -4290 180 -4290 210 {lab=#net1}
N -4290 170 -4290 180 {lab=#net1}
N -4290 170 -4230 170 {lab=#net1}
N -4230 170 -4230 210 {lab=#net1}
N -4260 210 -4260 230 {lab=VDD}
N -4280 230 -4260 230 {lab=VDD}
N -5640 210 -5630 210 {lab=#net1}
N -5640 170 -5640 210 {lab=#net1}
N -5670 170 -5640 170 {lab=#net1}
N -5650 330 -5630 330 {lab=#net1}
N -5680 370 -5650 370 {lab=#net1}
N -5650 330 -5650 370 {lab=#net1}
N -4250 310 -4250 330 {lab=VDD}
N -4280 310 -4250 310 {lab=VDD}
N -4310 330 -4280 330 {lab=#net1}
N -4280 330 -4280 370 {lab=#net1}
N -4280 370 -4220 370 {lab=#net1}
N -4220 330 -4220 370 {lab=#net1}
N -3660 210 -3640 210 {lab=V_SUM_P}
N -3660 330 -3640 330 {lab=V_SUM_N}
N -3800 210 -3720 210 {lab=#net2}
N -3800 330 -3720 330 {lab=#net2}
N -3690 170 -3610 170 {lab=V_NN}
N -3580 210 -3580 270 {lab=#net2}
N -3580 270 -3580 330 {lab=#net2}
N -3610 210 -3610 230 {lab=VDD}
N -3690 230 -3610 230 {lab=VDD}
N -3690 210 -3690 230 {lab=VDD}
N -3830 230 -3690 230 {lab=VDD}
N -3610 310 -3610 330 {lab=VDD}
N -3690 310 -3610 310 {lab=VDD}
N -3690 310 -3690 330 {lab=VDD}
N -3830 310 -3690 310 {lab=VDD}
N -3690 370 -3610 370 {lab=V_NP}
N -3960 130 -3560 130 {lab=V_SUM_N}
N -3650 330 -3650 400 {lab=V_SUM_N}
N -3970 410 -3570 410 {lab=V_SUM_N}
N -3960 150 -3560 150 {lab=V_NP}
N -3650 400 -3650 410 {lab=V_SUM_N}
N -3960 390 -3560 390 {lab=V_NP}
N -3690 370 -3690 380 {lab=V_NP}
N -3690 380 -3690 390 {lab=V_NP}
N -3960 110 -3560 110 {lab=V_NN}
N -3970 430 -3570 430 {lab=V_NN}
N -3690 110 -3690 170 {lab=V_NN}
N -3940 270 -3580 270 {lab=#net2}
N -3580 270 -3540 270 {lab=#net2}
N -3220 210 -3200 210 {lab=V_SUM_P}
N -3440 330 -3420 330 {lab=V_SUM_P}
N -3440 210 -3420 210 {lab=V_SUM_N}
N -3220 330 -3200 330 {lab=V_SUM_N}
N -3360 210 -3280 210 {lab=#net2}
N -3360 330 -3280 330 {lab=#net2}
N -3250 170 -3170 170 {lab=V_NN}
N -3470 370 -3390 370 {lab=V_NN}
N -3140 210 -3140 270 {lab=#net2}
N -3140 270 -3140 330 {lab=#net2}
N -3320 210 -3320 270 {lab=#net2}
N -3320 270 -3320 330 {lab=#net2}
N -3500 210 -3500 270 {lab=#net2}
N -3500 270 -3500 330 {lab=#net2}
N -3170 210 -3170 230 {lab=VDD}
N -3250 230 -3170 230 {lab=VDD}
N -3250 210 -3250 230 {lab=VDD}
N -3390 230 -3250 230 {lab=VDD}
N -3390 210 -3390 230 {lab=VDD}
N -3470 210 -3470 230 {lab=VDD}
N -3470 230 -3390 230 {lab=VDD}
N -3170 310 -3170 330 {lab=VDD}
N -3250 310 -3170 310 {lab=VDD}
N -3250 310 -3250 330 {lab=VDD}
N -3390 310 -3250 310 {lab=VDD}
N -3390 310 -3390 330 {lab=VDD}
N -3470 310 -3390 310 {lab=VDD}
N -3470 310 -3470 330 {lab=VDD}
N -3470 170 -3390 170 {lab=V_NP}
N -3250 370 -3170 370 {lab=V_NP}
N -3430 140 -3430 210 {lab=V_SUM_N}
N -3520 130 -3120 130 {lab=V_SUM_N}
N -3210 330 -3210 400 {lab=V_SUM_N}
N -3530 410 -3130 410 {lab=V_SUM_N}
N -3520 150 -3120 150 {lab=V_NP}
N -3390 160 -3390 170 {lab=V_NP}
N -3210 400 -3210 410 {lab=V_SUM_N}
N -3430 130 -3430 140 {lab=V_SUM_N}
N -3390 150 -3390 160 {lab=V_NP}
N -3520 390 -3120 390 {lab=V_NP}
N -3250 370 -3250 380 {lab=V_NP}
N -3250 380 -3250 390 {lab=V_NP}
N -3520 110 -3120 110 {lab=V_NN}
N -3530 430 -3130 430 {lab=V_NN}
N -3250 110 -3250 170 {lab=V_NN}
N -3390 370 -3390 430 {lab=V_NN}
N -3000 330 -2980 330 {lab=V_SUM_P}
N -3000 210 -2980 210 {lab=V_SUM_N}
N -2920 210 -2840 210 {lab=#net2}
N -2920 330 -2840 330 {lab=#net2}
N -3030 370 -2950 370 {lab=V_NN}
N -2880 210 -2880 270 {lab=#net2}
N -2880 270 -2880 330 {lab=#net2}
N -3060 210 -3060 270 {lab=#net2}
N -3060 270 -3060 330 {lab=#net2}
N -2950 230 -2810 230 {lab=VDD}
N -2950 210 -2950 230 {lab=VDD}
N -3030 210 -3030 230 {lab=VDD}
N -3030 230 -2950 230 {lab=VDD}
N -2950 310 -2810 310 {lab=VDD}
N -2950 310 -2950 330 {lab=VDD}
N -3030 310 -2950 310 {lab=VDD}
N -3030 310 -3030 330 {lab=VDD}
N -3030 170 -2950 170 {lab=V_NP}
N -2990 140 -2990 210 {lab=V_SUM_N}
N -3080 130 -2680 130 {lab=V_SUM_N}
N -3090 410 -2690 410 {lab=V_SUM_N}
N -3080 150 -2680 150 {lab=V_NP}
N -2950 160 -2950 170 {lab=V_NP}
N -2990 130 -2990 140 {lab=V_SUM_N}
N -2950 150 -2950 160 {lab=V_NP}
N -3080 390 -2680 390 {lab=V_NP}
N -3080 110 -2680 110 {lab=V_NN}
N -3090 430 -2690 430 {lab=V_NN}
N -2950 370 -2950 430 {lab=V_NN}
N -3140 210 -3060 210 {lab=#net2}
N -3120 150 -3080 150 {lab=V_NP}
N -3120 130 -3080 130 {lab=V_SUM_N}
N -3120 110 -3080 110 {lab=V_NN}
N -3120 390 -3080 390 {lab=V_NP}
N -3130 410 -3090 410 {lab=V_SUM_N}
N -3130 430 -3090 430 {lab=V_NN}
N -3060 270 -2700 270 {lab=#net2}
N -3540 270 -3180 270 {lab=#net2}
N -3180 270 -3140 270 {lab=#net2}
N -3140 270 -3060 270 {lab=#net2}
N -3140 330 -3060 330 {lab=#net2}
N -3560 110 -3520 110 {lab=V_NN}
N -3560 130 -3520 130 {lab=V_SUM_N}
N -3560 150 -3520 150 {lab=V_NP}
N -3560 390 -3520 390 {lab=V_NP}
N -3570 410 -3530 410 {lab=V_SUM_N}
N -3570 430 -3530 430 {lab=V_NN}
N -2640 130 -2240 130 {lab=V_SUM_N}
N -2650 410 -2250 410 {lab=V_SUM_N}
N -2640 150 -2240 150 {lab=V_NP}
N -2640 390 -2240 390 {lab=V_NP}
N -2640 110 -2240 110 {lab=V_NN}
N -2650 430 -2250 430 {lab=V_NN}
N -2200 130 -1800 130 {lab=V_SUM_N}
N -2210 410 -1810 410 {lab=V_SUM_N}
N -2200 150 -1800 150 {lab=V_NP}
N -2200 390 -1800 390 {lab=V_NP}
N -2200 110 -1800 110 {lab=V_NN}
N -2210 430 -1810 430 {lab=V_NN}
N -2240 150 -2200 150 {lab=V_NP}
N -2240 130 -2200 130 {lab=V_SUM_N}
N -2240 110 -2200 110 {lab=V_NN}
N -2240 390 -2200 390 {lab=V_NP}
N -2250 410 -2210 410 {lab=V_SUM_N}
N -2250 430 -2210 430 {lab=V_NN}
N -1760 130 -1360 130 {lab=V_SUM_N}
N -1770 410 -1370 410 {lab=V_SUM_N}
N -1760 150 -1360 150 {lab=V_NP}
N -1760 390 -1360 390 {lab=V_NP}
N -1760 110 -1360 110 {lab=V_NN}
N -1770 430 -1370 430 {lab=V_NN}
N -2560 210 -2480 210 {lab=#net2}
N -2560 330 -2480 330 {lab=#net2}
N -2590 230 -2450 230 {lab=VDD}
N -2590 310 -2450 310 {lab=VDD}
N -1320 130 -920 130 {lab=V_SUM_N}
N -1330 410 -930 410 {lab=V_SUM_N}
N -1320 150 -920 150 {lab=V_NP}
N -1320 390 -920 390 {lab=V_NP}
N -1320 110 -920 110 {lab=V_NN}
N -1330 430 -930 430 {lab=V_NN}
N -1360 150 -1320 150 {lab=V_NP}
N -1360 130 -1320 130 {lab=V_SUM_N}
N -1360 110 -1320 110 {lab=V_NN}
N -1360 390 -1320 390 {lab=V_NP}
N -1370 410 -1330 410 {lab=V_SUM_N}
N -1370 430 -1330 430 {lab=V_NN}
N -2700 270 -2340 270 {lab=#net2}
N -1800 110 -1760 110 {lab=V_NN}
N -1800 130 -1760 130 {lab=V_SUM_N}
N -1800 150 -1760 150 {lab=V_NP}
N -1800 390 -1760 390 {lab=V_NP}
N -1810 410 -1770 410 {lab=V_SUM_N}
N -1810 430 -1770 430 {lab=V_NN}
N -2680 110 -2640 110 {lab=V_NN}
N -2680 130 -2640 130 {lab=V_SUM_N}
N -2680 150 -2640 150 {lab=V_NP}
N -2680 390 -2640 390 {lab=V_NP}
N -2690 410 -2650 410 {lab=V_SUM_N}
N -2690 430 -2650 430 {lab=V_NN}
N -3580 210 -3500 210 {lab=#net2}
N -3580 330 -3500 330 {lab=#net2}
N -4040 130 -3960 130 {lab=V_SUM_N}
N -4040 410 -3970 410 {lab=V_SUM_N}
N -3980 450 -940 450 {lab=V_SUM_P}
N -2990 330 -2990 450 {lab=V_SUM_P}
N -3430 330 -3430 450 {lab=V_SUM_P}
N -3940 90 -900 90 {lab=V_SUM_P}
N -3650 90 -3650 210 {lab=V_SUM_P}
N -3210 90 -3210 210 {lab=V_SUM_P}
N -920 150 -920 390 {lab=V_NP}
N -930 410 -900 410 {lab=V_SUM_N}
N -900 130 -900 410 {lab=V_SUM_N}
N -920 130 -900 130 {lab=V_SUM_N}
N -920 110 -880 110 {lab=V_NN}
N -880 110 -880 430 {lab=V_NN}
N -930 430 -880 430 {lab=V_NN}
N -900 90 -860 90 {lab=V_SUM_P}
N -860 90 -860 450 {lab=V_SUM_P}
N -940 450 -860 450 {lab=V_SUM_P}
N -3610 230 -3470 230 {lab=VDD}
N -3830 230 -3830 310 {lab=VDD}
N -3960 150 -3960 390 {lab=V_NP}
N -2440 210 -2440 230 {lab=VDD}
N -2450 230 -2440 230 {lab=VDD}
N -2410 170 -2410 210 {lab=#net2}
N -2440 170 -2410 170 {lab=#net2}
N -2430 310 -2430 330 {lab=VDD}
N -2450 310 -2430 310 {lab=VDD}
N -2430 370 -2400 370 {lab=#net2}
N -2400 330 -2400 370 {lab=#net2}
N -3820 210 -3800 210 {lab=#net2}
N -3820 180 -3820 210 {lab=#net2}
N -3820 170 -3820 180 {lab=#net2}
N -3880 170 -3820 170 {lab=#net2}
N -3880 170 -3880 210 {lab=#net2}
N -3850 210 -3850 230 {lab=VDD}
N -3850 230 -3830 230 {lab=VDD}
N -2480 210 -2470 210 {lab=#net2}
N -2470 170 -2470 210 {lab=#net2}
N -2470 170 -2440 170 {lab=#net2}
N -2480 330 -2460 330 {lab=#net2}
N -2460 370 -2430 370 {lab=#net2}
N -2460 330 -2460 370 {lab=#net2}
N -3860 310 -3860 330 {lab=VDD}
N -3860 310 -3830 310 {lab=VDD}
N -3830 330 -3800 330 {lab=#net2}
N -3830 330 -3830 370 {lab=#net2}
N -3890 370 -3830 370 {lab=#net2}
N -3890 330 -3890 370 {lab=#net2}
N -4140 410 -4110 410 {lab=V_SUM_P}
N -4110 410 -4040 450 {lab=V_SUM_P}
N -4040 450 -3980 450 {lab=V_SUM_P}
N -4120 450 -4040 410 {lab=V_SUM_N}
N -4130 450 -4120 450 {lab=V_SUM_N}
N -4170 90 -4090 90 {lab=V_SUM_N}
N -4090 90 -4040 130 {lab=V_SUM_N}
N -4070 130 -4020 90 {lab=V_SUM_P}
N -4020 90 -3940 90 {lab=V_SUM_P}
N -4150 110 -4130 110 {lab=V_PN}
N -4130 110 -4130 430 {lab=V_PN}
N -4140 430 -4130 430 {lab=V_PN}
N -3980 110 -3960 110 {lab=V_NN}
N -3980 110 -3980 430 {lab=V_NN}
N -3980 430 -3970 430 {lab=V_NN}
N -4260 40 -4190 40 {lab=#net1}
N -4190 40 -4190 270 {lab=#net1}
N -3930 40 -3840 40 {lab=#net2}
N -3930 40 -3930 270 {lab=#net2}
N -3840 0 -3830 0 {lab=#net2}
N -680 -160 -680 -100 {lab=#net1}
N -4260 -100 -680 -100 {lab=#net1}
N -4260 -100 -4260 -0 {lab=#net1}
N -260 -160 -260 -40 {lab=#net2}
N -3830 -40 -260 -40 {lab=#net2}
N -3830 -40 -3830 -0 {lab=#net2}
N -4120 450 -4120 480 {lab=V_SUM_N}
N -4120 480 -190 480 {lab=V_SUM_N}
N -190 120 -190 480 {lab=V_SUM_N}
N -190 120 -40 120 {lab=V_SUM_N}
N -4040 450 -4040 520 {lab=V_SUM_P}
N -4040 520 -140 520 {lab=V_SUM_P}
N -140 140 -140 520 {lab=V_SUM_P}
N 1070 480 1110 480 {lab=V_OP}
N 1110 480 1200 480 {lab=V_OP}
N 1660 630 1660 920 {lab=V_PA}
N 1450 630 1660 630 {lab=V_PA}
N 1450 580 1450 630 {lab=V_PA}
N 1580 250 1970 250 {lab=VCM}
N 1570 490 1960 490 {lab=VCM}
N 1580 230 1970 230 {lab=V_OP}
N 1570 510 1960 510 {lab=V_OP}
N 1580 210 1970 210 {lab=V_CMFB}
N 1570 530 1960 530 {lab=V_CMFB}
N 1580 190 1970 190 {lab=V_PAD}
N 1570 550 1960 550 {lab=V_PAD}
N 2020 250 2410 250 {lab=VCM}
N 2010 490 2400 490 {lab=VCM}
N 2020 230 2410 230 {lab=V_OP}
N 2010 510 2400 510 {lab=V_OP}
N 2020 210 2410 210 {lab=V_CMFB}
N 2010 530 2400 530 {lab=V_CMFB}
N 2020 190 2410 190 {lab=V_PAD}
N 2010 550 2400 550 {lab=V_PAD}
N 1970 250 2020 250 {lab=VCM}
N 1970 230 2020 230 {lab=V_OP}
N 1970 210 2020 210 {lab=V_CMFB}
N 1970 190 2020 190 {lab=V_PAD}
N 1960 490 2010 490 {lab=VCM}
N 1960 510 2010 510 {lab=V_OP}
N 1960 530 2010 530 {lab=V_CMFB}
N 1960 550 2010 550 {lab=V_PAD}
N 2620 310 2660 310 {lab=V_PA}
N 2620 430 2660 430 {lab=V_PA}
N 2440 370 2870 370 {lab=V_PA}
N 2640 310 2640 370 {lab=V_PA}
N 2640 370 2640 430 {lab=V_PA}
N 2470 310 2470 370 {lab=V_PA}
N 2470 370 2470 430 {lab=V_PA}
N 2810 310 2810 370 {lab=V_PA}
N 2810 370 2810 430 {lab=V_PA}
N 2530 310 2560 310 {lab=V_CMFB}
N 2530 430 2560 430 {lab=V_PAD}
N 2720 430 2750 430 {lab=V_CMFB}
N 2720 310 2750 310 {lab=V_PAD}
N 2500 270 2590 270 {lab=VCM}
N 2500 250 2500 270 {lab=VCM}
N 2450 250 2840 250 {lab=VCM}
N 2690 470 2780 470 {lab=VCM}
N 2780 470 2780 490 {lab=VCM}
N 2440 490 2830 490 {lab=VCM}
N 2450 230 2840 230 {lab=V_OP}
N 2690 270 2780 270 {lab=V_OP}
N 2780 230 2780 270 {lab=V_OP}
N 2440 510 2830 510 {lab=V_OP}
N 2500 470 2590 470 {lab=V_OP}
N 2500 470 2500 510 {lab=V_OP}
N 2500 410 2500 430 {lab=VSS}
N 2500 410 2780 410 {lab=VSS}
N 2780 410 2780 430 {lab=VSS}
N 2690 410 2690 430 {lab=VSS}
N 2590 410 2590 430 {lab=VSS}
N 2500 310 2500 330 {lab=VSS}
N 2500 330 2780 330 {lab=VSS}
N 2780 310 2780 330 {lab=VSS}
N 2690 310 2690 330 {lab=VSS}
N 2590 310 2590 330 {lab=VSS}
N 2450 210 2840 210 {lab=V_CMFB}
N 2550 210 2550 310 {lab=V_CMFB}
N 2440 530 2830 530 {lab=V_CMFB}
N 2730 430 2730 530 {lab=V_CMFB}
N 2450 190 2840 190 {lab=V_PAD}
N 2730 190 2730 310 {lab=V_PAD}
N 2440 550 2830 550 {lab=V_PAD}
N 2540 430 2540 550 {lab=V_PAD}
N 3060 310 3100 310 {lab=V_PA}
N 3060 430 3100 430 {lab=V_PA}
N 3080 310 3080 370 {lab=V_PA}
N 3080 370 3080 430 {lab=V_PA}
N 2910 310 2910 370 {lab=V_PA}
N 2910 370 2910 430 {lab=V_PA}
N 3250 310 3250 370 {lab=V_PA}
N 3250 370 3250 430 {lab=V_PA}
N 2970 310 3000 310 {lab=V_CMFB}
N 2970 430 3000 430 {lab=V_PAD}
N 3160 430 3190 430 {lab=V_CMFB}
N 3160 310 3190 310 {lab=V_PAD}
N 2940 270 3030 270 {lab=VCM}
N 2940 250 2940 270 {lab=VCM}
N 2890 250 3280 250 {lab=VCM}
N 3130 470 3220 470 {lab=VCM}
N 3220 470 3220 490 {lab=VCM}
N 2880 490 3270 490 {lab=VCM}
N 2890 230 3280 230 {lab=V_OP}
N 3130 270 3220 270 {lab=V_OP}
N 3220 230 3220 270 {lab=V_OP}
N 2880 510 3270 510 {lab=V_OP}
N 2940 470 3030 470 {lab=V_OP}
N 2940 470 2940 510 {lab=V_OP}
N 2940 410 2940 430 {lab=VSS}
N 2940 410 3220 410 {lab=VSS}
N 3220 410 3220 430 {lab=VSS}
N 3130 410 3130 430 {lab=VSS}
N 3030 410 3030 430 {lab=VSS}
N 2940 310 2940 330 {lab=VSS}
N 2940 330 3220 330 {lab=VSS}
N 3220 310 3220 330 {lab=VSS}
N 3130 310 3130 330 {lab=VSS}
N 3030 310 3030 330 {lab=VSS}
N 2890 210 3280 210 {lab=V_CMFB}
N 2990 210 2990 310 {lab=V_CMFB}
N 2880 530 3270 530 {lab=V_CMFB}
N 3170 430 3170 530 {lab=V_CMFB}
N 2890 190 3280 190 {lab=V_PAD}
N 3170 190 3170 310 {lab=V_PAD}
N 2880 550 3270 550 {lab=V_PAD}
N 2980 430 2980 550 {lab=V_PAD}
N 2870 370 2880 370 {lab=V_PA}
N 2840 250 2890 250 {lab=VCM}
N 2840 230 2890 230 {lab=V_OP}
N 2840 210 2890 210 {lab=V_CMFB}
N 2840 190 2890 190 {lab=V_PAD}
N 2830 490 2880 490 {lab=VCM}
N 2830 510 2880 510 {lab=V_OP}
N 2830 530 2880 530 {lab=V_CMFB}
N 2830 550 2880 550 {lab=V_PAD}
N 2410 190 2450 190 {lab=V_PAD}
N 2410 210 2450 210 {lab=V_CMFB}
N 2410 230 2450 230 {lab=V_OP}
N 2410 250 2450 250 {lab=VCM}
N 2400 490 2440 490 {lab=VCM}
N 2400 510 2440 510 {lab=V_OP}
N 2400 530 2440 530 {lab=V_CMFB}
N 2400 550 2440 550 {lab=V_PAD}
N 1550 490 1570 490 {lab=VCM}
N 1550 250 1550 490 {lab=VCM}
N 1550 250 1580 250 {lab=VCM}
N 1530 230 1580 230 {lab=V_OP}
N 1530 230 1530 510 {lab=V_OP}
N 1530 510 1570 510 {lab=V_OP}
N 1510 210 1580 210 {lab=V_CMFB}
N 1510 210 1510 530 {lab=V_CMFB}
N 1510 530 1570 530 {lab=V_CMFB}
N 1490 190 1580 190 {lab=V_PAD}
N 1490 190 1490 550 {lab=V_PAD}
N 1490 550 1570 550 {lab=V_PAD}
N 2880 370 2910 370 {lab=V_PA}
N 2910 370 3080 370 {lab=V_PA}
N 3080 370 3250 370 {lab=V_PA}
N 2780 330 2940 330 {lab=VSS}
N 2350 330 2500 330 {lab=VSS}
N 2350 410 2500 410 {lab=VSS}
N 2780 410 2940 410 {lab=VSS}
N 4650 250 5040 250 {lab=VCM}
N 4660 490 5050 490 {lab=VCM}
N 4650 230 5040 230 {lab=V_ON}
N 4660 510 5050 510 {lab=V_ON}
N 4650 210 5040 210 {lab=V_CMFB}
N 4660 530 5050 530 {lab=V_CMFB}
N 4650 190 5040 190 {lab=V_NAD}
N 4660 550 5050 550 {lab=V_NAD}
N 4210 250 4600 250 {lab=VCM}
N 4220 490 4610 490 {lab=VCM}
N 4210 230 4600 230 {lab=V_ON}
N 4220 510 4610 510 {lab=V_ON}
N 4210 210 4600 210 {lab=V_CMFB}
N 4220 530 4610 530 {lab=V_CMFB}
N 4210 190 4600 190 {lab=V_NAD}
N 4220 550 4610 550 {lab=V_NAD}
N 4600 250 4650 250 {lab=VCM}
N 4600 230 4650 230 {lab=V_ON}
N 4600 210 4650 210 {lab=V_CMFB}
N 4600 190 4650 190 {lab=V_NAD}
N 4610 490 4660 490 {lab=VCM}
N 4610 510 4660 510 {lab=V_ON}
N 4610 530 4660 530 {lab=V_CMFB}
N 4610 550 4660 550 {lab=V_NAD}
N 3960 310 4000 310 {lab=V_NA}
N 3960 430 4000 430 {lab=V_NA}
N 3750 370 4180 370 {lab=V_NA}
N 3980 310 3980 370 {lab=V_NA}
N 3980 370 3980 430 {lab=V_NA}
N 4150 310 4150 370 {lab=V_NA}
N 4150 370 4150 430 {lab=V_NA}
N 3810 310 3810 370 {lab=V_NA}
N 3810 370 3810 430 {lab=V_NA}
N 4060 310 4090 310 {lab=V_CMFB}
N 4060 430 4090 430 {lab=V_NAD}
N 3870 430 3900 430 {lab=V_CMFB}
N 3870 310 3900 310 {lab=V_NAD}
N 4030 270 4120 270 {lab=VCM}
N 4120 250 4120 270 {lab=VCM}
N 3780 250 4170 250 {lab=VCM}
N 3840 470 3930 470 {lab=VCM}
N 3840 470 3840 490 {lab=VCM}
N 3790 490 4180 490 {lab=VCM}
N 3780 230 4170 230 {lab=V_ON}
N 3840 270 3930 270 {lab=V_ON}
N 3840 230 3840 270 {lab=V_ON}
N 3790 510 4180 510 {lab=V_ON}
N 4030 470 4120 470 {lab=V_ON}
N 4120 470 4120 510 {lab=V_ON}
N 4120 410 4120 430 {lab=VSS}
N 3840 410 4120 410 {lab=VSS}
N 3840 410 3840 430 {lab=VSS}
N 3930 410 3930 430 {lab=VSS}
N 4030 410 4030 430 {lab=VSS}
N 4120 310 4120 330 {lab=VSS}
N 3840 330 4120 330 {lab=VSS}
N 3840 310 3840 330 {lab=VSS}
N 3930 310 3930 330 {lab=VSS}
N 4030 310 4030 330 {lab=VSS}
N 3780 210 4170 210 {lab=V_CMFB}
N 4070 210 4070 310 {lab=V_CMFB}
N 3790 530 4180 530 {lab=V_CMFB}
N 3890 430 3890 530 {lab=V_CMFB}
N 3780 190 4170 190 {lab=V_NAD}
N 3890 190 3890 310 {lab=V_NAD}
N 3790 550 4180 550 {lab=V_NAD}
N 4080 430 4080 550 {lab=V_NAD}
N 3520 310 3560 310 {lab=V_NA}
N 3520 430 3560 430 {lab=V_NA}
N 3540 310 3540 370 {lab=V_NA}
N 3540 370 3540 430 {lab=V_NA}
N 3710 310 3710 370 {lab=V_NA}
N 3710 370 3710 430 {lab=V_NA}
N 3370 310 3370 370 {lab=V_NA}
N 3370 370 3370 430 {lab=V_NA}
N 3620 310 3650 310 {lab=V_CMFB}
N 3620 430 3650 430 {lab=V_NAD}
N 3430 430 3460 430 {lab=V_CMFB}
N 3430 310 3460 310 {lab=V_NAD}
N 3590 270 3680 270 {lab=VCM}
N 3680 250 3680 270 {lab=VCM}
N 3340 250 3730 250 {lab=VCM}
N 3400 470 3490 470 {lab=VCM}
N 3400 470 3400 490 {lab=VCM}
N 3350 490 3740 490 {lab=VCM}
N 3340 230 3730 230 {lab=V_ON}
N 3400 270 3490 270 {lab=V_ON}
N 3400 230 3400 270 {lab=V_ON}
N 3350 510 3740 510 {lab=V_ON}
N 3590 470 3680 470 {lab=V_ON}
N 3680 470 3680 510 {lab=V_ON}
N 3680 410 3680 430 {lab=VSS}
N 3400 410 3680 410 {lab=VSS}
N 3400 410 3400 430 {lab=VSS}
N 3490 410 3490 430 {lab=VSS}
N 3590 410 3590 430 {lab=VSS}
N 3680 310 3680 330 {lab=VSS}
N 3400 330 3680 330 {lab=VSS}
N 3400 310 3400 330 {lab=VSS}
N 3490 310 3490 330 {lab=VSS}
N 3590 310 3590 330 {lab=VSS}
N 3340 210 3730 210 {lab=V_CMFB}
N 3630 210 3630 310 {lab=V_CMFB}
N 3350 530 3740 530 {lab=V_CMFB}
N 3450 430 3450 530 {lab=V_CMFB}
N 3340 190 3730 190 {lab=V_NAD}
N 3450 190 3450 310 {lab=V_NAD}
N 3350 550 3740 550 {lab=V_NAD}
N 3640 430 3640 550 {lab=V_NAD}
N 3740 370 3750 370 {lab=V_NA}
N 3730 250 3780 250 {lab=VCM}
N 3730 230 3780 230 {lab=V_ON}
N 3730 210 3780 210 {lab=V_CMFB}
N 3730 190 3780 190 {lab=V_NAD}
N 3740 490 3790 490 {lab=VCM}
N 3740 510 3790 510 {lab=V_ON}
N 3740 530 3790 530 {lab=V_CMFB}
N 3740 550 3790 550 {lab=V_NAD}
N 4170 190 4210 190 {lab=V_NAD}
N 4170 210 4210 210 {lab=V_CMFB}
N 4170 230 4210 230 {lab=V_ON}
N 4170 250 4210 250 {lab=VCM}
N 4180 490 4220 490 {lab=VCM}
N 4180 510 4220 510 {lab=V_ON}
N 4180 530 4220 530 {lab=V_CMFB}
N 4180 550 4220 550 {lab=V_NAD}
N 5050 490 5070 490 {lab=VCM}
N 5070 250 5070 490 {lab=VCM}
N 5040 250 5070 250 {lab=VCM}
N 5040 230 5090 230 {lab=V_ON}
N 5090 230 5090 510 {lab=V_ON}
N 5050 510 5090 510 {lab=V_ON}
N 5040 210 5110 210 {lab=V_CMFB}
N 5110 210 5110 530 {lab=V_CMFB}
N 5050 530 5110 530 {lab=V_CMFB}
N 5040 190 5130 190 {lab=V_NAD}
N 5130 190 5130 550 {lab=V_NAD}
N 5050 550 5130 550 {lab=V_NAD}
N 3710 370 3740 370 {lab=V_NA}
N 3540 370 3710 370 {lab=V_NA}
N 3370 370 3540 370 {lab=V_NA}
N 3680 330 3840 330 {lab=VSS}
N 4120 330 4270 330 {lab=VSS}
N 4120 410 4270 410 {lab=VSS}
N 3680 410 3840 410 {lab=VSS}
N 3280 250 3340 250 {lab=VCM}
N 3270 490 3350 490 {lab=VCM}
N 3280 210 3340 210 {lab=V_CMFB}
N 3270 530 3350 530 {lab=V_CMFB}
N 1450 370 1570 370 {lab=V_PA}
N 4330 370 4490 370 {lab=V_NA}
N 1450 370 1450 580 {lab=V_PA}
N 1200 480 1530 480 {lab=V_OP}
N 1870 630 1870 900 {lab=V_NA}
N 1870 630 5220 630 {lab=V_NA}
N 4500 370 4500 630 {lab=V_NA}
N 4490 370 4500 370 {lab=V_NA}
N 3280 110 3280 190 {lab=V_PAD}
N 3340 110 3340 190 {lab=V_NAD}
N 2250 410 2250 430 {lab=VSS}
N 2280 430 2280 470 {lab=V_PA}
N 2250 470 2280 470 {lab=V_PA}
N 2220 470 2250 470 {lab=V_PA}
N 2220 430 2220 470 {lab=V_PA}
N 4300 430 4430 430 {lab=V_NA}
N 4430 430 4430 470 {lab=V_NA}
N 4430 470 4460 470 {lab=V_NA}
N 4490 430 4490 470 {lab=V_NA}
N 4460 470 4490 470 {lab=V_NA}
N 4460 410 4460 430 {lab=VSS}
N 4270 410 4460 410 {lab=VSS}
N 4270 330 4470 330 {lab=VSS}
N 4470 310 4470 330 {lab=VSS}
N 4300 310 4440 310 {lab=V_NA}
N 4440 270 4440 310 {lab=V_NA}
N 4440 270 4470 270 {lab=V_NA}
N 4470 270 4500 270 {lab=V_NA}
N 4500 270 4500 310 {lab=V_NA}
N 3310 150 3310 210 {lab=V_CMFB}
N 90 160 90 1030 {lab=V_SUM_P}
N 90 160 100 160 {lab=V_SUM_P}
N 100 150 100 160 {lab=V_SUM_P}
N 340 150 340 1030 {lab=V_SUM_N}
N 330 1030 340 1030 {lab=V_SUM_N}
N 1090 970 1870 970 {lab=V_NA}
N 1870 900 1870 970 {lab=V_NA}
N 730 920 1660 920 {lab=V_PA}
N 730 920 730 970 {lab=V_PA}
N 700 1030 730 1030 {lab=VSS}
N 1090 1030 1120 1030 {lab=VSS}
N 490 480 1070 480 {lab=V_OP}
N 490 30 490 480 {lab=V_OP}
N 3310 70 3310 150 {lab=V_CMFB}
N 920 -20 920 50 {lab=V_CMFB}
N 920 50 3310 50 {lab=V_CMFB}
N 3310 50 3310 70 {lab=V_CMFB}
N 470 30 490 30 {lab=V_OP}
N 640 0 640 100 {lab=V_PAD}
N 640 100 3280 100 {lab=V_PAD}
N 3280 100 3280 110 {lab=V_PAD}
N 3340 80 3340 110 {lab=V_NAD}
N 1190 80 3340 80 {lab=V_NAD}
N 1190 0 1190 70 {lab=V_NAD}
N 1190 70 1190 80 {lab=V_NAD}
N 3260 270 3260 310 {lab=V_PA}
N 3260 270 3320 270 {lab=V_PA}
N 3320 270 3320 310 {lab=V_PA}
N 3340 430 3370 430 {lab=V_NA}
N 3340 430 3340 560 {lab=V_NA}
N 3330 560 3340 560 {lab=V_NA}
N 3300 560 3330 560 {lab=V_NA}
N 3300 560 3300 600 {lab=V_NA}
N 3360 560 3360 600 {lab=V_NA}
N 3360 560 3440 560 {lab=V_NA}
N 3440 560 3440 600 {lab=V_NA}
N 3340 560 3360 560 {lab=V_NA}
N 3330 600 3330 610 {lab=VSS}
N 3330 610 3410 610 {lab=VSS}
N 3410 600 3410 610 {lab=VSS}
N 3390 610 3390 620 {lab=VSS}
N 3390 620 3520 620 {lab=VSS}
N 3360 600 3380 600 {lab=V_NA}
N 3290 310 3290 330 {lab=VSS}
N 3220 330 3290 330 {lab=VSS}
N 3250 310 3260 310 {lab=V_PA}
N 3250 430 3260 430 {lab=V_PA}
N 3260 430 3260 470 {lab=V_PA}
N 3260 470 3320 470 {lab=V_PA}
N 3320 430 3320 470 {lab=V_PA}
N 3290 410 3290 430 {lab=VSS}
N 3220 410 3290 410 {lab=VSS}
N -4390 210 -4390 270 {lab=#net1}
N -4390 270 -4390 330 {lab=#net1}
N -3720 210 -3720 270 {lab=#net2}
N -3720 270 -3720 330 {lab=#net2}
N 2250 410 2350 410 {lab=VSS}
N 2250 310 2250 330 {lab=VSS}
N 2250 330 2350 330 {lab=VSS}
N 2280 310 2320 310 {lab=V_PA}
N 2280 430 2320 430 {lab=V_PA}
N 2220 270 2220 310 {lab=V_PA}
N 2220 270 2280 270 {lab=V_PA}
N 2280 270 2280 310 {lab=V_PA}
N 2320 310 2470 310 {lab=V_PA}
N 2320 430 2470 430 {lab=V_PA}
N 1570 370 2440 370 {lab=V_PA}
N 4150 310 4290 310 {lab=V_NA}
N 4290 310 4300 310 {lab=V_NA}
N 4180 370 4330 370 {lab=V_NA}
N 4150 430 4300 430 {lab=V_NA}
N 3400 330 3400 410 {lab=VSS}
N 3290 330 3290 410 {lab=VSS}
N -5520 230 -5300 230 {lab=VDD}
N -5550 210 -5270 210 {lab=#net1}
N -5520 310 -5300 310 {lab=VDD}
N -5550 330 -5270 330 {lab=#net1}
N -5080 230 -4940 230 {lab=VDD}
N -5080 310 -4940 310 {lab=VDD}
N -4640 310 -4500 310 {lab=VDD}
N -2810 230 -2590 230 {lab=VDD}
N -2840 210 -2560 210 {lab=#net2}
N -2810 310 -2590 310 {lab=VDD}
N -2840 330 -2560 330 {lab=#net2}
N -3170 310 -3030 310 {lab=VDD}
N -3170 230 -3030 230 {lab=VDD}
N -3610 310 -3470 310 {lab=VDD}
C {iopin.sym} 910 1000 0 0 {name=p4 lab=V_B2}
C {iopin.sym} -50 -320 0 0 {name=p14 lab=VDD}
C {iopin.sym} -600 1160 0 1 {name=p15 lab=VSS}
C {lab_pin.sym} 220 -210 3 1 {name=p26 sig_type=std_logic lab=V_CMFB}
C {lab_wire.sym} 30 50 0 0 {name=p22 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 420 50 0 1 {name=p23 sig_type=std_logic lab=VSS}
C {iopin.sym} 220 -90 3 0 {name=p5 lab=V_B4}
C {iopin.sym} 220 30 3 0 {name=p19 lab=V_B3}
C {iopin.sym} -480 -190 3 0 {name=p3 lab=V_B1}
C {lab_pin.sym} 790 -80 3 1 {name=p7 sig_type=std_logic lab=V_CMFB}
C {lab_pin.sym} 210 1090 1 1 {name=p20 sig_type=std_logic lab=V_B2}
C {lab_pin.sym} 60 -10 2 1 {name=p18 sig_type=std_logic lab=V_ON}
C {ipin.sym} -7190 220 2 1 {name=p21 lab=V_PP}
C {ipin.sym} -7230 190 0 0 {name=p24 lab=V_PN}
C {ipin.sym} -920 260 2 0 {name=p25 lab=V_NP}
C {ipin.sym} -880 180 2 0 {name=p27 lab=V_NN}
C {sky130_fd_pr/pfet_01v8.sym} -4500 190 3 1 {name=A5
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4420 190 1 0 {name=A6
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4500 350 3 0 {name=B7
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4420 350 1 1 {name=B8
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4940 190 3 1 {name=A9
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4860 190 1 0 {name=A10
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4720 350 3 0 {name=A11
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4640 350 1 1 {name=A12
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4720 190 3 1 {name=B9
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4640 190 1 0 {name=B10
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4940 350 3 0 {name=B11
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4860 350 1 1 {name=B12
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5160 350 3 0 {name=A15
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5080 350 1 1 {name=A16
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5160 190 3 1 {name=B13
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5080 190 1 0 {name=B14
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5670 190 3 1 {name=B49
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5680 350 3 0 {name=A49
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4260 190 1 0 {name=A50
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4250 350 1 1 {name=B50
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3610 190 1 0 {name=A1
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3690 190 3 1 {name=A2
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3610 350 1 1 {name=B1
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3690 350 3 0 {name=B2
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3170 190 1 0 {name=A3
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3250 190 3 1 {name=A4
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3390 350 1 1 {name=A7
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3470 350 3 0 {name=A8
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3390 190 1 0 {name=B3
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3470 190 3 1 {name=B4
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3170 350 1 1 {name=B5
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3250 350 3 0 {name=B6
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2950 350 1 1 {name=A33
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3030 350 3 0 {name=A34
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2950 190 1 0 {name=B31
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3030 190 3 1 {name=B32
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2440 190 1 0 {name=B51
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2430 350 1 1 {name=A51
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3850 190 3 1 {name=A52
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3860 350 3 0 {name=B52
W=9.46
L=0.3
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -4010 520 3 1 {name=p33 sig_type=std_logic lab=V_SUM_P}
C {lab_pin.sym} -7110 90 3 1 {name=p34 sig_type=std_logic lab=V_SUM_N}
C {sky130_fd_pr/nfet_01v8.sym} 2500 290 1 0 {name=J9
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2590 290 3 1 {name=J10
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2500 450 1 1 {name=O9
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2590 450 3 0 {name=O10
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2690 290 1 0 {name=O11
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 290 3 1 {name=O12
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2690 450 1 1 {name=J11
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 450 3 0 {name=J12
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2940 290 1 0 {name=J13
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3030 290 3 1 {name=J14
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2940 450 1 1 {name=O13
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3030 450 3 0 {name=O14
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3130 290 1 0 {name=O15
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3220 290 3 1 {name=O16
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3130 450 1 1 {name=J15
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3220 450 3 0 {name=J16
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {opin.sym} 1530 230 3 0 {name=p2 lab=V_OP}
C {iopin.sym} 1550 250 3 0 {name=p10 lab=VCM
W=1.32}
C {sky130_fd_pr/nfet_01v8.sym} 4120 290 3 1 {name=J25
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4030 290 1 0 {name=J26
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4120 450 3 0 {name=O25
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4030 450 1 1 {name=O26
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3930 290 3 1 {name=O27
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3840 290 1 0 {name=O28
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3930 450 3 0 {name=J27
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3840 450 1 1 {name=J28
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3680 290 3 1 {name=J29
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3590 290 1 0 {name=J30
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3680 450 3 0 {name=O29
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3590 450 1 1 {name=O30
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3490 290 3 1 {name=O31
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3400 290 1 0 {name=O32
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3490 450 3 0 {name=J31
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3400 450 1 1 {name=J32
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {opin.sym} 5090 240 0 0 {name=p40 lab=V_ON
W=1.32}
C {sky130_fd_pr/nfet_01v8.sym} 2250 290 3 1 {name=J33
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2250 450 3 0 {name=O33
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4470 290 3 1 {name=J34
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4460 450 1 1 {name=O34
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1660 810 2 1 {name=p6 sig_type=std_logic lab=V_PA}
C {lab_pin.sym} 1870 810 2 0 {name=p8 sig_type=std_logic lab=V_NA}
C {sky130_fd_pr/nfet_01v8.sym} 3290 290 3 1 {name=O35
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3290 450 3 0 {name=O36
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3330 580 1 0 {name=O37
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3410 580 1 0 {name=O38
W=1.36
L=0.15
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 100 -130 2 1 {name=p9 sig_type=std_logic lab=V_NE}
C {lab_pin.sym} 340 -130 0 1 {name=p12 sig_type=std_logic lab=V_PE}
C {lab_pin.sym} 640 10 0 1 {name=p16 sig_type=std_logic lab=V_PAD}
C {lab_pin.sym} 1190 10 0 1 {name=p17 sig_type=std_logic lab=V_NAD}
C {lab_wire.sym} 3520 620 0 1 {name=p32 sig_type=std_logic lab=VSS
W=1.36
L=0.15}
C {lab_wire.sym} -4340 230 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -3780 230 0 0 {name=p28 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2340 330 0 0 {name=p1 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2350 410 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4290 330 0 0 {name=p29 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4300 410 0 0 {name=p30 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/pfet_01v8.sym} -660 -190 0 1 {name=MP11
W=2.55
L=0.7
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -280 -190 0 0 {name=MP12
W=2.55
L=0.7
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 120 -190 0 1 {name=MP5
W=0.84
L=0.4
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 320 -190 0 0 {name=MP6
W=0.84
L=0.4
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 120 -70 0 1 {name=MP7
W=0.69
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 320 -70 0 0 {name=MP8
W=0.69
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 120 50 0 1 {name=MN1
W=0.66
L=3
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 320 50 0 0 {name=MN2
W=0.66
L=3
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 110 1070 0 1 {name=MN3
W=2.48
L=2
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 310 1070 0 0 {name=MN4
W=2.48
L=2
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 750 1030 0 1 {name=MN5
W=2.48
L=2
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1070 1030 0 0 {name=MN6
W=2.48
L=2
nf=1 
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 620 -100 0 0 {name=MP1
W=1.97
L=0.4
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 900 -100 0 0 {name=MP2
W=3.94
L=0.4
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1210 -100 0 1 {name=MP3
W=1.97
L=0.4
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
